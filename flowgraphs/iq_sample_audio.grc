options:
  parameters:
    author: martin
    generate_options: no_gui
    id: iq_sample_audio
    output_language: python
    run_options: run
    title: ZMQ Pipeline test receive
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate)
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: zeromq_sub_source_1
  id: zeromq_sub_source
  parameters:
    address: ipc://@out_float.sock
    timeout: '100'
    type: float
  states: {}

connections:
- [blocks_throttle2_0, '0', audio_sink_0, '0']
- [zeromq_sub_source_1, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
