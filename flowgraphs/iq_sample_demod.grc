options:
  parameters:
    author: martin
    generate_options: no_gui
    id: iq_sample_demod
    output_language: python
    run_options: run
    title: ZMQ Pipeline test receive
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '8192'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '1'
    type: ccc
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: ipc://@out_float.sock
    timeout: '100'
    type: float
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: ipc://@out_short.sock
    timeout: '100'
    type: short
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: ipc://@iq_samples.sock
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_float_to_short_0, '0']
- [blocks_complex_to_float_0, '0', zeromq_pub_sink_0, '0']
- [blocks_float_to_short_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle2_0, '0']
- [zeromq_sub_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
